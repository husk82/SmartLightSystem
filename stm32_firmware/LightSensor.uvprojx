# Keil uVision project LightSensor.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LightSensor
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Src
    ./: main.c
  group Drivers
    ./: GPIO_Driver.c GPIO_Driver_H.h EXTI_Driver.h EXTI_Driver.c I2C_Driver_H.h I2C_Driver.c TIM_Driver_H.h TIM_Driver.c USART_Driver_H.h USART_Driver.c
  group TSLLightSensor
    ./: TSL2591.c TSL2591_H.h
  group OLEDSSD1306
    ./: SSD1306_H.h SSD1306.c font_H.h font.c
  group Secrets
    ./: SECRETS_H.h
  group ESP
    ./: ESP.c ESP_H.h
software components: CMSIS:CORE 6.1.0, Device:Startup 2.6.3
